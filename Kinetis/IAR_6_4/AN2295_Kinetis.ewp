# IAR project AN2295_Kinetis.ewp, settings and files
configuration Kinetis KL46 Debug (ARM, debug)
  General.OGChipSelectEditMenu: MKL46Z256xxx4 Freescale MKL46Z256xxx4
  ICCARM.CCDefines: KINETIS_L; KINETIS_KL46
  ICCARM.CCIncludePath2: ..\CommonSource\headers; ..\CommonSource\wdg; ..\CommonSource\flash; ..\CommonSource\crc; ..\CommonSource\rs232; ..\CommonSource\bootloader; ..\CommonSource\
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: AN2295_Kinetis.srec
  ILINK.IlinkOutputFile: AN2295_KinetisL.out
  ILINK.IlinkIcfFile: IAR_Linker_cfg\AN2295_LinkerFile.icf
  ILINK.IlinkProgramEntryLabel: __main
configuration Kinetis KL46 Release (ARM)
  as the first configuration, except:
  General.OGChipSelectEditMenu: MKL25Z32xxx4 Freescale MKL25Z32xxx4
  ICCARM.CCOptLevel: 3
configuration Kinetis KL25 Debug (ARM, debug)
  as the first configuration, except:
  General.OGChipSelectEditMenu: MKL25Z32xxx4 Freescale MKL25Z32xxx4
  ICCARM.CCDefines: KINETIS_L; KINETIS_KL25
  ICCARM.CCOptLevel: 0
  ILINK.IlinkIcfFile: IAR_Linker_cfg\4KB_RAM.icf
configuration Kinetis KL25 Release (ARM)
  as the first configuration, except:
  General.OGChipSelectEditMenu: MKL25Z32xxx4 Freescale MKL25Z32xxx4
  ICCARM.CCDefines: KINETIS_L; KINETIS_KL25
  ICCARM.CCOptLevel: 3
configuration Kinetis KE02 Debug (ARM, debug)
  as the first configuration, except:
  General.OGChipSelectEditMenu: MKE02Z32xxx2 Freescale MKE02Z32xxx2
  ICCARM.CCDefines: KINETIS_E; KINETIS_KE02; FLASH_ENABLE_STALLING_FLASH_CONTROLLER
  OBJCOPY.OOCOutputFile: AN2295_Kinetis_KE.srec
  ILINK.IlinkIcfFile: IAR_Linker_cfg\4KB_RAM.icf
configuration Kinetis KE02 Release (ARM)
  as the first configuration, except:
  General.OGChipSelectEditMenu: MKL25Z32xxx4 Freescale MKL25Z32xxx4
  ICCARM.CCDefines: KINETIS_E; KINETIS_KE02
  ICCARM.CCOptLevel: 3
configuration Kinetis K 100MHz Debug (ARM, debug)
  as the first configuration, except:
  General.OGChipSelectEditMenu: MK60DN512xxx10 Freescale MK60DN512xxx10
  ICCARM.CCDefines: KINETIS_K=0x10
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  OBJCOPY.OOCOutputFile: AN2295_KinetisK60.srec
  ILINK.IlinkOutputFile: AN2295_Kinetis.out
  ILINK.IlinkIcfFile: IAR_Linker_cfg\4KB_RAM.icf
configuration Kinetis K 100MHz Release (ARM)
  as the first configuration, except:
  General.OGChipSelectEditMenu: MK60DN512xxx10 Freescale MK60DN512xxx10
  ICCARM.CCDefines: KINETIS_K=0x10
  ICCARM.CCOptLevel: 3
  OBJCOPY.OOCOutputFile: AN2295_Kinetis.s19
  ILINK.IlinkOutputFile: AN2295_Kinetis.out
configuration Kinetis KL26 Debug (ARM, debug)
  as the first configuration, except:
  General.OGChipSelectEditMenu: MKL25Z32xxx4 Freescale MKL25Z32xxx4
  ICCARM.CCDefines: KINETIS_L; KINETIS_KL26
configuration Kinetis KL26 Release (ARM)
  as the first configuration, except:
  General.OGChipSelectEditMenu: MKL25Z32xxx4 Freescale MKL25Z32xxx4
  ICCARM.CCDefines: KINETIS_L; KINETIS_KL26
  ICCARM.CCOptLevel: 3
  group (top)
    IAR_Linker_cfg/: AN2295_LinkerFile.icf
    ../CommonSource/: main.h
  group BootCfg
    ../CommonSource/: AN2295_FRDM_KE02Z_cfg.h AN2295_FRDM_KL25Z_cfg.h AN2295_FRDM_KL26Z_cfg.h AN2295_FRDM_KL46Z_cfg.h AN2295_TWR_K60_cfg.h AN2295_TWR_K60D100_cfg.h AN2295_TWR_KL25_cfg.h bootloader_cfg.h
  group Bootloader
    ../CommonSource/bootloader/: bootloader.c bootloader.h kinetis_params.h
  group CRC
    ../CommonSource/crc/: crc.c crc.h
  group FLASH
    ../CommonSource/flash/: flash_kinetis.c flash_kinetis.h flash_kinetisRamFunc.c
  group headers
    ../CommonSource/headers/: MK10D5.h MK10DZ10.h MK10F12.h MK20D5.h MK20DZ10.h MK20F12.h MK22F10.h MK30DZ10.h MK40DZ10.h MK50DZ10.h MK51DZ10.h MK52DZ10.h MK53DZ10.h MK60D10.h MK60DZ10.h MK60F12.h MK60F15.h MK61F12.h MK61F15.h MK70F12.h MK70F15.h MKL05Z32LF4.h MKL25Z128LK4.h MKL25Z4.h MKM34Z5.h
  group RS232
    ../CommonSource/rs232/: rs232.c rs232.h
  group WDG
    ../CommonSource/wdg/: wdg.h
